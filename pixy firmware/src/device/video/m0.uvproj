# Keil uVision project m0.uvproj, settings and files
target m0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: m0 +hex
  AfterMake: fromelf --cadcombined --output="m0_image.c" ".\m0\m0.axf"
  c flags: Optim=1 OneElfS=1
  c define: CORE_M0  IPC_SLAVE PIXY
  c include: ., ..\libpixy, ..\..\common
  asm define: NO_CRP  IPC_SLAVE
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x2000 size 0x2000
  group Source Code
    ./: main_m0.c startup_LPC43xx_m0.s
    ../libpixy/: libpixy_m0.lib qqueue.c exec_m0.c frame_m0.c rls_m0.c
